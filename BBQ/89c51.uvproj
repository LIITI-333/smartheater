# Keil uVision project 89c51.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 89c51 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c first.h DS18B20.c LCD.c DELAY.c OLED12864.h OLED12864.c CodeTab0.h CodeTab0.c DS1302.h DS1302.c
